VERSION 5.7 ;
# Local site declarations derived directly from the installed GF180 I/O LEF
# macro SITE names and exact 75x350 / 355x355 geometry.  The installed macro
# LEFs reference these sites but do not ship a separate site-definition LEF.
SITE GF_IO_Site
  CLASS PAD ;
  SIZE 75.000 BY 350.000 ;
  SYMMETRY X Y R90 ;
END GF_IO_Site
SITE GF_COR_Site
  CLASS PAD ;
  SIZE 355.000 BY 355.000 ;
  SYMMETRY X Y R90 ;
END GF_COR_Site
END LIBRARY
